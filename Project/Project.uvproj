# Keil uVision project Project.uvproj, settings and files
target Stm32f407VG (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER , STM32F40XX, USE_EMBEDDED_PHY, USE_USB_OTG_FS
  c include: ..\Stm32_Library\inc;..\Stm32_Library\src;..\Basic;..\Source_Code;..\User_Library\inc;..\User_Library\src;..\Stm32_Library\STM32_USB_OTG_Driver\inc;..\Stm32_Library\STM32_USB_Device_Library\Class\cdc\inc;..\Stm32_Library\STM32_USB_Device_Library\Core\inc;..\Source_Code\inc;..\Stm32_Library\STM32_USB_HOST_Library\Core\inc;..\Stm32_Library\STM32_USB_HOST_Library\Class\HID\inc;..\PrinterCode;..\PrinterCode\inc;..\PrinterCode\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f4xx.s
  group Source Code
    ../Source_Code/: main.c
    ../Source_Code/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group Stm32_Library
    ../Stm32_Library/src/: stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_adc.c
  group Basic
    ../Basic/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c general.h hardware.h
  group User_Library
    ../User_Library/src/: WorkMemory.c Uart_Hardware.c Delay.c cronometer.c GPIO_User.c
  group USB DRIVER
    ../Stm32_Library/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_dcd.c usb_core.c
  group USB DEVICE
    ../Stm32_Library/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Stm32_Library/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group PrintCode
    ../PrinterCode/src/: fonts.c header_hardware.c
